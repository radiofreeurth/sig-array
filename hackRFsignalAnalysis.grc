options:
  parameters:
    author: radiofreeurth
    generate_options: qt_gui
    id: signalAnalysis_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bw
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,15,1,5
    label: Bandwidth
    type: real
    value: 20e3
  states: {}
- name: cf
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,5
    label: Center Freq (MHz)
    type: real
    value: '101.3'
  states: {}
- name: cfshift
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,10
    label: Center Freq Shift (Hz)
    start: '-2000'
    step: '1'
    stop: '2000'
    value: '0'
  states: {}
- name: demodSelect
  id: variable_qtgui_chooser
  parameters:
    gui_hint: mt@3:0,0,1,10
    label: Demod Selection
    label0: AM Full Carrier
    label1: AM-SC-SSB
    label2: AM-SC-DSB
    label3: FM
    label4: FM Double Demod
    num_opts: '5'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,5,1,10
    label: RF Gain (dB)
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,10,1,10
    label: Volume (dB)
    start: '-80'
    step: '0.1'
    stop: '50'
    value: '0'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate/10)/(2*math.pi*250e3)
  states: {}
- name: analog_quadrature_demod_cf_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate/10)/(2*math.pi*250e3)
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: cfshift
    sample_rate: 48e3
  states: {}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: 67e3
    sample_rate: (samp_rate/20)
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume Control
    const: 10**(vol/20)
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: demodSelect
    num_inputs: '5'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    comment: Takes out the DC offset.
    length: '320'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 6.28/100
  states: {}
- name: filter_fft_low_pass_filter_0_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: filter_fft_low_pass_filter_0_0_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: filter_fft_low_pass_filter_0_0_1
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: 45e3
    win: window.WIN_HAMMING
  states: {}
- name: mt
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,20,20
    label0: RF
    label1: Constellation
    label2: Zoomed Spectrum
    label3: Demod Selection
    label4: ''
    num_tabs: '5'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: This row demods AM full carrier
    note: AM Full Carrier
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: This row demods AM single sideband suppressed carrier
    note: AM-SSB Suppressed Carrier
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    comment: This row demods AM double sideband suppressed carrier
    note: AM-DSB Suppressed Carrier
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    comment: FM demodulation
    note: FM Demod
  states: {}
- name: note_0_0_0_0_0
  id: note
  parameters:
    comment: FM double demodulation
    note: FM Demod
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: cf*1e6
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: mt@1
    size: '5000'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    axislabels: 'False'
    bw: 100e3
    comment: Freezes everything. Maybe compute power issue.
    fc: cf*1e6
    fftsize: '2048'
    gui_hint: mt@0:0,0,10,10
    legend: 'False'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/10
    fc: cf*1e6
    fftsize: '8192'
    gui_hint: mt@2
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: mt@3:1,0,20,20
    size: '1024'
    srate: 48e3
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: mt@0:10,0,10,10
    legend: 'False'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Input SR: 8MHz
      Output SR: 800kHz
    decim: '10'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '800'
    interp: '48'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    alias: rr
    decim: '800'
    interp: '48'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '800'
    interp: '48'
    type: ccf
  states: {}
- name: rational_resampler_xxx_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '800'
    interp: '48'
    type: ccf
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '80'
    interp: '48'
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ampModulated
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: ampModulated
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: ampModulated
  states: {}

connections:
- [analog_agc_xx_0, '0', qtgui_const_sink_x_0, '0']
- [analog_agc_xx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', blocks_float_to_complex_0, '0']
- [analog_quadrature_demod_cf_0_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [blocks_complex_to_arg_0, '0', rational_resampler_xxx_2, '0']
- [blocks_complex_to_mag_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_selector_0, '1']
- [blocks_complex_to_real_0_0, '0', blocks_selector_0, '2']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_float_to_complex_0, '0', blocks_freqshift_cc_0_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_complex_to_real_0, '0']
- [blocks_freqshift_cc_0_0, '0', filter_fft_low_pass_filter_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_selector_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [dc_blocker_xx_0, '0', blocks_selector_0, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_complex_to_real_0_0, '0']
- [filter_fft_low_pass_filter_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [filter_fft_low_pass_filter_0_0_0, '0', analog_quadrature_demod_cf_0_0_0, '0']
- [filter_fft_low_pass_filter_0_0_1, '0', analog_agc_xx_0, '0']
- [filter_fft_low_pass_filter_0_0_1, '0', qtgui_freq_sink_x_0, '1']
- [filter_fft_low_pass_filter_0_0_1, '0', rational_resampler_xxx_0, '0']
- [filter_fft_low_pass_filter_0_0_1, '0', virtual_sink_0, '0']
- [osmosdr_source_0, '0', filter_fft_low_pass_filter_0_0_1, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0, '0', dc_blocker_xx_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_selector_0, '4']
- [rational_resampler_xxx_0_1, '0', blocks_freqshift_cc_0, '0']
- [rational_resampler_xxx_0_1_0, '0', analog_agc_xx_0_0, '0']
- [rational_resampler_xxx_1, '0', blocks_delay_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_2, '0', blocks_selector_0, '3']
- [virtual_source_0, '0', blocks_complex_to_mag_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0_1, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0_1_0, '0']
- [virtual_source_0_0, '0', filter_fft_low_pass_filter_0_0, '0']
- [virtual_source_0_0, '0', rational_resampler_xxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
